# Keil uVision project 19UARTPC2MCU.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 19UARTPC2MCU +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c matrixKey.c matrixKey.h LCD1602.c LCD1602.h
    ../18UART/: Delay.c Delay.h UART.c UART.h

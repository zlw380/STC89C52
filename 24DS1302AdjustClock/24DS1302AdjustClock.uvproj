# Keil uVision project 24DS1302AdjustClock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 24DS1302AdjustClock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS1302.c DS1302.h LCD1602.c LCD1602.h Key.c Key.h Timer0.c Timer0.h Delay.c Delay.h
